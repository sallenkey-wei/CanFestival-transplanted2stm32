# Keil uVision project OLED.uvprojx, settings and files
target OLED (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OLED +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE\BEEP;..\HARDWARE\ADC;..\HARDWARE\PWM;..\HARDWARE\CAN;..\HARDWARE\RGB;..\HARDWARE\EXTI;..\CanFestival\inc;..\CanFestival\inc\stm32;..\CanFestival\driver;..\HARDWARE\TIMER3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/PWM/: timpwm.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/RGB/: ws2811_rgb.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/CAN/: can_hw.c
    ../HARDWARE/TIMER3/: timer3.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_iwdg.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_exti.c
  group README
    ../: README.TXT
  group CanFestival_src
    ../CanFestival/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
  group CanFestival_driver
    ../CanFestival/driver/: stm32_canfestival.c TestMaster.c
